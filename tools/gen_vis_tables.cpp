// gen_vis_tables.cpp — görsel tabloları üretir: stdout'a fv_vis_tables_gen.cpp yazar.
// Kullanım: gen_vis_tables > core/src/fv_vis_tables_gen.cpp  (drift testi karşılaştırır)
#include <cmath>
#include <cstdint>
#include <cstdio>

static const uint8_t kFont[96][5] = {
  {0x00,0x00,0x00,0x00,0x00}, {0x00,0x00,0x5F,0x00,0x00}, {0x00,0x07,0x00,0x07,0x00}, {0x14,0x7F,0x14,0x7F,0x14},  // sp ! " #
  {0x24,0x2A,0x7F,0x2A,0x12}, {0x23,0x13,0x08,0x64,0x62}, {0x36,0x49,0x56,0x20,0x50}, {0x00,0x05,0x03,0x00,0x00},  // $ % & '
  {0x00,0x1C,0x22,0x41,0x00}, {0x00,0x41,0x22,0x1C,0x00}, {0x14,0x08,0x3E,0x08,0x14}, {0x08,0x08,0x3E,0x08,0x08},  // ( ) * +
  {0x00,0x80,0x60,0x00,0x00}, {0x08,0x08,0x08,0x08,0x08}, {0x00,0x60,0x60,0x00,0x00}, {0x20,0x10,0x08,0x04,0x02},  // , - . /
  {0x3E,0x51,0x49,0x45,0x3E}, {0x00,0x42,0x7F,0x40,0x00}, {0x42,0x61,0x51,0x49,0x46}, {0x21,0x41,0x45,0x4B,0x31},  // 0 1 2 3
  {0x18,0x14,0x12,0x7F,0x10}, {0x27,0x45,0x45,0x45,0x39}, {0x3C,0x4A,0x49,0x49,0x30}, {0x01,0x71,0x09,0x05,0x03},  // 4 5 6 7
  {0x36,0x49,0x49,0x49,0x36}, {0x06,0x49,0x49,0x29,0x1E}, {0x00,0x36,0x36,0x00,0x00}, {0x00,0x80,0x76,0x36,0x00},  // 8 9 : ;
  {0x08,0x14,0x22,0x41,0x00}, {0x14,0x14,0x14,0x14,0x14}, {0x00,0x41,0x22,0x14,0x08}, {0x02,0x01,0x51,0x09,0x06},  // < = > ?
  {0x32,0x49,0x79,0x41,0x3E}, {0x7E,0x11,0x11,0x11,0x7E}, {0x7F,0x49,0x49,0x49,0x36}, {0x3E,0x41,0x41,0x41,0x22},  // @ A B C
  {0x7F,0x41,0x41,0x22,0x1C}, {0x7F,0x49,0x49,0x49,0x41}, {0x7F,0x09,0x09,0x09,0x01}, {0x3E,0x41,0x49,0x49,0x7A},  // D E F G
  {0x7F,0x08,0x08,0x08,0x7F}, {0x00,0x41,0x7F,0x41,0x00}, {0x20,0x40,0x41,0x3F,0x01}, {0x7F,0x08,0x14,0x22,0x41},  // H I J K
  {0x7F,0x40,0x40,0x40,0x40}, {0x7F,0x02,0x0C,0x02,0x7F}, {0x7F,0x04,0x08,0x10,0x7F}, {0x3E,0x41,0x41,0x41,0x3E},  // L M N O
  {0x7F,0x09,0x09,0x09,0x06}, {0x3E,0x41,0x51,0x21,0x5E}, {0x7F,0x09,0x19,0x29,0x46}, {0x46,0x49,0x49,0x49,0x31},  // P Q R S
  {0x01,0x01,0x7F,0x01,0x01}, {0x3F,0x40,0x40,0x40,0x3F}, {0x1F,0x20,0x40,0x20,0x1F}, {0x3F,0x40,0x38,0x40,0x3F},  // T U V W
  {0x63,0x14,0x08,0x14,0x63}, {0x07,0x08,0x70,0x08,0x07}, {0x61,0x51,0x49,0x45,0x43}, {0x00,0x7F,0x41,0x41,0x00},  // X Y Z [
  {0x02,0x04,0x08,0x10,0x20}, {0x00,0x41,0x41,0x7F,0x00}, {0x04,0x02,0x01,0x02,0x04}, {0x40,0x40,0x40,0x40,0x40},  // \ ] ^ _
  {0x00,0x01,0x02,0x04,0x00}, {0x20,0x54,0x54,0x54,0x78}, {0x7F,0x48,0x44,0x44,0x38}, {0x38,0x44,0x44,0x44,0x20},  // ` a b c
  {0x38,0x44,0x44,0x48,0x7F}, {0x38,0x54,0x54,0x54,0x18}, {0x08,0x7E,0x09,0x01,0x02}, {0x18,0xA4,0xA4,0x9C,0x78},  // d e f g
  {0x7F,0x08,0x04,0x04,0x78}, {0x00,0x44,0x7D,0x40,0x00}, {0x40,0x80,0x84,0x7D,0x00}, {0x7F,0x10,0x28,0x44,0x00},  // h i j k
  {0x00,0x41,0x7F,0x40,0x00}, {0x7C,0x04,0x18,0x04,0x78}, {0x7C,0x08,0x04,0x04,0x78}, {0x38,0x44,0x44,0x44,0x38},  // l m n o
  {0xFC,0x24,0x24,0x24,0x18}, {0x18,0x24,0x24,0x24,0xFC}, {0x7C,0x08,0x04,0x04,0x08}, {0x48,0x54,0x54,0x54,0x20},  // p q r s
  {0x04,0x3F,0x44,0x40,0x20}, {0x3C,0x40,0x40,0x20,0x7C}, {0x1C,0x20,0x40,0x20,0x1C}, {0x3C,0x40,0x30,0x40,0x3C},  // t u v w
  {0x44,0x28,0x10,0x28,0x44}, {0x1C,0xA0,0xA0,0xA0,0x7C}, {0x44,0x64,0x54,0x4C,0x44}, {0x00,0x08,0x36,0x41,0x00},  // x y z {
  {0x00,0x00,0x7F,0x00,0x00}, {0x00,0x41,0x36,0x08,0x00}, {0x08,0x08,0x2A,0x1C,0x08}, {0x7F,0x41,0x41,0x41,0x7F},  // | } ~ DEL
};

int main() {
  std::printf("// fv_vis_tables_gen.cpp — ÜRETİLMİŞ DOSYA, elle düzenleme (tools/gen_vis_tables.cpp).\n");
  std::printf("#include \"fv_vis_tables.h\"\nnamespace fv { namespace vtab {\n\n");

  // gamma 2.2 (8 bit ve 16 bit)
  std::printf("const uint8_t gamma22[256] = {");
  for (int i = 0; i < 256; ++i) {
    std::printf("%s%d,", i % 16 ? " " : "\n  ", (int)std::lround(255.0 * std::pow(i / 255.0, 2.2)));
  }
  std::printf("\n};\n\n");
  std::printf("const uint16_t gamma22w[256] = {");
  for (int i = 0; i < 256; ++i) {
    std::printf("%s%d,", i % 12 ? " " : "\n  ", (int)std::lround(65535.0 * std::pow(i / 255.0, 2.2)));
  }
  std::printf("\n};\n\n");

  // CodePen nokta boyutu² yasası: cp(e) = 3 + 252*((1+19e)/20)^2
  std::printf("const uint8_t cpBright[256] = {");
  for (int i = 0; i < 256; ++i) {
    double e = i / 255.0, q = (1.0 + 19.0 * e) / 20.0;
    std::printf("%s%d,", i % 16 ? " " : "\n  ", (int)std::lround(3.0 + 252.0 * q * q));
  }
  std::printf("\n};\n\n");

  // ısı paleti: siyah → kırmızı → turuncu/sarı → beyaz (hafif eğri: ateş gibi uzun kırmızı/sarı bölge)
  std::printf("const uint8_t heatPal[256][3] = {");
  for (int i = 0; i < 256; ++i) {
    double t = i / 255.0 * 3.0;
    double r = t < 1 ? t : 1.0;
    double g = t < 1 ? 0.0 : (t < 2 ? t - 1.0 : 1.0);
    double b = t < 2 ? 0.0 : t - 2.0;
    r = std::pow(r, 0.85); g = std::pow(g, 1.15); b = std::pow(b, 1.4);
    std::printf("%s{%d,%d,%d},", i % 6 ? " " : "\n  ", (int)std::lround(255 * r), (int)std::lround(255 * g), (int)std::lround(255 * b));
  }
  std::printf("\n};\n\n");

  // Fisher–Yates, xorshift32 seed 0xC0DE
  uint8_t p[120];
  for (int i = 0; i < 120; ++i) p[i] = (uint8_t)i;
  uint32_t s = 0xC0DE;
  for (int i = 119; i > 0; --i) {
    s ^= s << 13; s ^= s >> 17; s ^= s << 5;
    int j = (int)(s % (uint32_t)(i + 1));
    uint8_t t = p[i]; p[i] = p[j]; p[j] = t;
  }
  std::printf("const uint8_t perm120[NUM_LEDS] = {");
  for (int i = 0; i < 120; ++i) std::printf("%s%d,", i % 20 ? " " : "\n  ", p[i]);
  std::printf("\n};\n\n");

  // 5x7 font, ASCII 32..127, sütun bazlı, LSB üstte
  std::printf("const uint8_t font5x7[96][5] = {");
  for (int i = 0; i < 96; ++i) {
    std::printf("\n  {0x%02X,0x%02X,0x%02X,0x%02X,0x%02X},", kFont[i][0], kFont[i][1], kFont[i][2], kFont[i][3], kFont[i][4]);
  }
  std::printf("\n};\n\n}}  // namespace fv::vtab\n");
  return 0;
}
